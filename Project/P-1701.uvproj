# Keil uVision project P-1701.uvproj, settings and files
target project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: P-1701 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\System;..\User;..\Hwa;..\Drivers;..\App;..\FM1702
  link misc: REMOVEUNUSED
  group System
    ../System/: sys_eeprom.c sys_delay.c sys_uart.c
  group User
    ../User/: main.c
  group Hwa
    ../Hwa/: hwa_eeprom.c hwa_eeprom_cfg.c hwa_uart.c
  group Driver
    ../Drivers/: drive_buzzer.c drive_led.c drive_relay.c
  group App
    ../App/: app_brush.c app_config.c app_time.c app_test.c
  group FM1702
    ../FM1702/: drv_fm1702.c drv_fm1702_itf.c hwa_fm1702.c
